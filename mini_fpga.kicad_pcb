# Repository emusan/FPGA_HDMI-pcb

File README.md:

# FPGA HDMI Experimenting Board PCB Layout Files

Note that this project is still in progress. Most of the work on the schematic
is finished, with the pcb layout being the priority right now.

This board is designed to be relatively cheap (compared to other FPGA options 
with HDMI), and be fairly small at 2x2in. To meet these requirements some corners
were cut (like ESD protection on the HDMI), though it still should function well.

This is not intended to be a consumer device, but rather a development and
experimenting platform for those interested in playing around with HDMI.

# ENJOY!

## KiCad design mini_fpga.kicad_pcb

Parts:
C1, C2, C5, C8, C12, C17, C18, C19, C20, C21, C22, C24: 4.7u
C3, C7: 10u
C4, C6: 100p
C9, C10, C11, C13, C14, C15, C16: .47u
C23, C25, C26, C27, C28, C29: 100u
D1: LED
J1: PWR_HEADER1X6
L1, L2: 2.2u
R1: 340k1%
R2, R6: 120k1%
R3: 200k1%
R4: 100k1%
R5: 510k .5%
R7: 330
R59: 30k .5%
R60: 40k1%
U1: AP7331
U2: PAM2306D
U3: XC6SLX9

Connections:
+1.2V: C5.1, C10.1, C12.1, C18.1, C24.1, C29.1, J1.5 (+1.2V), R3.1, U1.4 (OUT), U3.F9 (VCCINT), U3.G6 (VCCINT), U3.G8 (VCCINT), U3.H7 (VCCINT), U3.H9 (VCCINT), U3.J8 (VCCINT), U3.J10 (VCCINT), U3.K7 (VCCINT)
+2.5V: C3.1, C4.1, C16.1, C22.1, C28.1, J1.4 (+2.5V), L2.1, R1.1, U3.D2 (VCCO_3), U3.G4 (VCCO_3), U3.H2 (VCCO_3), U3.M2 (VCCO_3); also elsewhere on the board
+3.3V: C1.1, C6.1, C7.1, C9.1, C11.1, C13.1, C14.1, C15.1, C17.1, C19.1, C20.1, C21.1, C23.1, C25.1, C26.1, C27.1, D1.1 (A), J1.3 (+3.3V), L1.2, R5.1, U1.1 (EN), U1.3 (IN), U3.B1 (VCCAUX), U3.B4 (VCCO_0), U3.B8 (VCCO_0), U3.B12 (VCCO_0), U3.D9 (VCCO_0), U3.D14 (VCCO_1), U3.E12 (VCCAUX), U3.F7 (VCCAUX), U3.G10 (VCCAUX), U3.H14 (VCCO_1), U3.J6 (VCCAUX), U3.J12 (VCCO_1), U3.K9 (VCCAUX), U3.L4 (VCCAUX), U3.M7 (VCCO_2), U3.M12 (VCCAUX), U3.M14 (VCCO_1), U3.P4 (VCCO_2), U3.P8 (VCCO_2), U3.P12 (VCCO_2); also elsewhere on the board
+5V: C2.1, C8.1, J1.2 (+5V), U2.1 (VIN2), U2.6 (EN1), U2.7 (VIN1), U2.12 (EN2)
GND: C1.2, C2.2, C3.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, J1.1 (GND), J1.6 (GND), R2.2, R4.2, R6.2, R7.2, U1.2 (GND), U2.3 (GND), U2.9 (GND), U2.PAD (GND), U3.A1 (GND), U3.A15 (GND), U3.B6 (GND), U3.B10 (GND), U3.C3 (GND), U3.C13 (GND), U3.E11 (GND), U3.F2 (GND), U3.F6 (GND), U3.F14 (GND), U3.G7 (GND), U3.G9 (GND), U3.H8 (GND), U3.J7 (GND), U3.J9 (GND), U3.K2 (GND), U3.K6 (GND), U3.K14 (GND), U3.L11 (GND), U3.N3 (GND), U3.N13 (GND), U3.P6 (GND), U3.P10 (GND), U3.R1 (GND), U3.R15 (GND); also elsewhere on the board
unnamed: C6.2, R6.1, R59.2, U2.10 (FB2)
unnamed: L1.1, U2.2 (LX2)
unnamed: L2.2, U2.8 (LX1)
unnamed: D1.2 (K), R7.1
unnamed: R3.2, R4.1, U1.6 (ADJ)
unnamed: C4.2, R2.1, R60.2, U2.4 (FB1)
unnamed: R1.2, R60.1
unnamed: R5.2, R59.1

Notes on the sheet:
Power status LED

Parts:
C30, C32, C46, C47: .1u
C31, C35: .47u
C33, C34, C36, C37, C38, C39, C40, C41, C42, C43: 4.7u
C44, C45: 100u
R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R32, R33, R34, R35, R36, R37: 50
R31: 100
R38, R39: 1K 1%
U3: XC6SLX9
U4: IS43R86400D-6TL

Connections:
+2.5V: C31.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, R38.1, U4.1 (V_DD), U4.3 (V_DDQ), U4.9 (V_DDQ), U4.15 (V_DDQ), U4.18 (VDD), U4.33 (VDD), U4.55 (V_DDQ), U4.61 (V_DDQ); also elsewhere on the board
/memory/FPGA_A9_FPGA: R33.1, U3.E1 (IO_L52N_M3A9_3)
/memory/RAM_A0: R27.2, U4.29 (A0)
/memory/RAM_A0_FPGA: R27.1, U3.J5 (IO_L47P_M3A0_3)
/memory/RAM_A1: R28.2, U4.30 (A1)
/memory/RAM_A1_FPGA: R28.1, U3.H4 (IO_L47N_M3A1_3)
/memory/RAM_A2: R30.2, U4.31 (A2)
/memory/RAM_A2_FPGA: R30.1, U3.H5 (IO_L49N_M3A2_3)
/memory/RAM_A3: R22.2, U4.32 (A3)
/memory/RAM_A3_FPGA: R22.1, U3.K5 (IO_L45P_M3A3_3)
/memory/RAM_A4: R24.2, U4.35 (A4)
/memory/RAM_A4_FPGA: R24.1, U3.E4 (IO_L51N_M3A4_3)
/memory/RAM_A5: R13.2, U4.36 (A5)
/memory/RAM_A5_FPGA: R13.1, U3.G2 (IO_L44P_GCLK21_M3A5_3)
/memory/RAM_A6: R14.2, U4.37 (A6)
/memory/RAM_A6_FPGA: R14.1, U3.G1 (IO_L44N_GCLK20_M3A6_3)
/memory/RAM_A7: R29.2, U4.38 (A7)
/memory/RAM_A7_FPGA: R29.1, U3.H6 (IO_L49P_M3A7_3)
/memory/RAM_A8: R32.2, U4.39 (A8)
/memory/RAM_A8_FPGA: R32.1, U3.E2 (IO_L52P_M3A8_3)
/memory/RAM_A9: R33.2, U4.40 (A9)
/memory/RAM_A10: R23.2, U4.28 (A10/AP)
/memory/RAM_A10_FPGA: R23.1, U3.E5 (IO_L51P_M3A10_3)
/memory/RAM_A11: R34.2, U4.41 (A11)
/memory/RAM_A11_FPGA: R34.1, U3.D1 (IO_L54N_M3A11_3)
/memory/RAM_A12: R26.2, U4.42 (A12)
/memory/RAM_A12_FPGA: R26.1, U3.E3 (IO_L53N_M3A12_3)
/memory/RAM_BA0: R35.2, U4.26 (BA0)
/memory/RAM_BA0_FPGA: R35.1, U3.G5 (IO_L48P_M3BA0_3)
/memory/RAM_BA1: R36.2, U4.27 (BA1)
/memory/RAM_BA1_FPGA: R36.1, U3.G3 (IO_L48N_M3BA1_3)
/memory/RAM_CAS_FPGA: R21.1, U3.J3 (IO_L43N_GCLK22_IRDY_2_M3CASN_3)
/memory/RAM_CKE: R25.2, U4.44 (CKE)
/memory/RAM_CKE_FPGA: R25.1, U3.D4 (IO_L53P_M3CKE_3)
/memory/RAM_CLK: R31.1, U3.F3 (IO_L46P_M3CLK_3), U4.45 (CK)
/memory/RAM_CLKN: R31.2, U3.F1 (IO_L46N_M3CLKN_3), U4.46 (~CK~)
/memory/RAM_DM: R12.2, U4.47 (DM)
/memory/RAM_DM_FPGA: R12.1, U3.H1 (IO_L42N_GCLK24_M3LDM_3)
/memory/RAM_DQ0: R15.2, U4.2 (DQ0)
/memory/RAM_DQ0_FPGA: R15.1, U3.N2 (IO_L37P_M3DQ0_3)
/memory/RAM_DQ1: R16.2, U4.5 (DQ1)
/memory/RAM_DQ1_FPGA: R16.1, U3.N1 (IO_L37N_M3DQ1_3)
/memory/RAM_DQ2: R8.2, U4.8 (DQ2)
/memory/RAM_DQ2_FPGA: R8.1, U3.M3 (IO_L38P_M3DQ2_3)
/memory/RAM_DQ3: R9.2, U4.11 (DQ3)
/memory/RAM_DQ3_FPGA: R9.1, U3.M1 (IO_L38N_M3DQ3_3)
/memory/RAM_DQ4: R18.2, U4.56 (DQ4)
/memory/RAM_DQ4_FPGA: R18.1, U3.J2 (IO_L41P_GCLK27_M3DQ4_3)
/memory/RAM_DQ5: R19.2, U4.59 (DQ5)
/memory/RAM_DQ5_FPGA: R19.1, U3.J1 (IO_L41N_GCLK26_M3DQ5_3)
/memory/RAM_DQ6: R10.2, U4.62 (DQ6)
/memory/RAM_DQ6_FPGA: R10.1, U3.K3 (IO_L40P_M3DQ6_3)
/memory/RAM_DQ7: R11.2, U4.65 (DQ7)
/memory/RAM_DQ7_FPGA: R11.1, U3.K1 (IO_L40N_M3DQ7_3)
/memory/RAM_DQS: R17.2, U4.51 (DQS)
/memory/RAM_DQS_FPGA: R17.1, U3.L2 (IO_L39P_M3LQDS_3)
/memory/RAM_RAS_FPGA: R20.1, U3.K4 (IO_L43P_GCLK23_M3RASN_3)
/memory/RAM_WE_FPGA: R37.1, U3.F5 (IO_L50P_M3WE_3)
/memory/RAM_~CAS~: R21.2, U4.22 (~CAS~)
/memory/RAM_~RAS~: R20.2, U4.23 (~RAS~)
/memory/RAM_~WE~: R37.2, U4.21 (~WE~)
/memory/Vref: C30.2, C32.1, C46.2, C47.1, R38.2, R39.1, U3.C1 (IO_L83N_VREF_3), U3.L3 (IO_L1N_VREF_3), U4.49 (VREF)
GND: C30.1, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C47.2, R39.2, U4.6 (V_SSQ), U4.12 (V_SSQ), U4.24 (~CS~), U4.34 (VSS), U4.48 (VSS), U4.52 (V_SSQ), U4.58 (V_SSQ), U4.64 (V_SSQ), U4.66 (V_SS); also elsewhere on the board

Parts:
D2, D3, D4: LED
J2, J3: 1X6_HEADER
R40, R41, R42: 330
R51, R52, R53, R54, R55, R56, R57, R58: 50
U3: XC6SLX9

Connections:
+3.3V: J2.6 (VCC), J3.6 (VCC); also elsewhere on the board
GND: J2.5 (GND), J3.5 (GND), R40.1, R41.1, R42.1; also elsewhere on the board
unnamed: D4.1 (A), U3.H10 (IO_L32P_A17_M1A8_1)
unnamed: D3.2 (K), R41.2
unnamed: D3.1 (A), U3.F12 (IO_L31N_A18_M1A12_1)
unnamed: D2.1 (A), U3.F11 (IO_L31P_A19_M1CKE_1)
unnamed: D4.2 (K), R42.2
unnamed: R51.1, U3.F13 (IO_L39P_M1A3_1)
unnamed: J2.1 (D1), R51.2
unnamed: R52.1, U3.F15 (IO_L39N_M1ODT_1)
unnamed: J2.2 (D2), R52.2
unnamed: R53.1, U3.K12 (IO_L40P_GCLK11_M1A5_1)
unnamed: R54.1, U3.L12 (IO_L40N_GCLK10_M1A6_1)
unnamed: R58.1, U3.M15 (IO_L46N_FOE_B_M1DQ3_1)
unnamed: D2.2 (K), R40.2
unnamed: R55.1, U3.L14 (IO_L45P_A1_M1LDQS_1)
unnamed: R56.1, U3.L15 (IO_L45N_A0_M1LDQSN_1)
unnamed: J3.2 (D2), R56.2
unnamed: J3.1 (D1), R55.2
unnamed: J3.3 (D3), R57.2
unnamed: J3.4 (D4), R58.2
unnamed: J2.3 (D3), R53.2
unnamed: J2.4 (D4), R54.2
unnamed: R57.1, U3.M13 (IO_L46P_FCS_B_M1DQ2_1)

Parts:
C48: .01u
C49, C50: 100n
J4: JTAG_1X6
J5: USD_SLOT
R43, R44, R45: 100
R46: 330
R47, R48, R49, R50: 4.7K
U3: XC6SLX9
U5: S25FL164
U6: CPPC7

Connections:
+3.3V: C48.1, C49.1, C50.1, J4.5 (VCC), J5.4, R44.2, R46.1, R48.2, R49.2, R50.2, U3.R12 (IO_L1N_M0_CMPMISO_2), U5.3 (WP#/IO2), U5.7 (HOLD#/IO3), U5.8 (VCC), U6.1 (CONTROL), U6.4 (Vdd); also elsewhere on the board
/control/programming/CS: R50.1, U3.R3 (IO_L64N_CSO_B_2), U5.1 (CS#)
GND: C48.2, C49.2, C50.2, J4.6 (GND), J5.6, R45.1, R47.1, U3.L13 (SUSPEND), U3.N10 (IO_L13P_M1_2), U5.4 (VSS), U6.2 (GND); also elsewhere on the board
unnamed: J5.3, U3.P5 (IO_L49P_D3_2)
unnamed: J5.5, U3.R5 (IO_L49N_D4_2)
unnamed: J5.7, U3.L6 (IO_L62P_D5_2)
unnamed: J5.8, U3.L5 (IO_L62N_D6_2)
unnamed: J5.2, U3.R6 (IO_L48N_RDWR_B_VREF_2)
unnamed: J5.1, U3.N6 (IO_L48P_D7_2)
unnamed: U3.M8 (IO_L30P_GCLK1_D13_2), U6.3 (OUT)
unnamed: J4.1 (TCK), U3.A14 (TCK)
unnamed: J4.4 (TDO), U3.D12 (TDO)
unnamed: J4.3 (TMS), U3.E13 (TMS)
unnamed: J4.2 (TDI), U3.E10 (TDI)
unnamed: U3.R11 (IO_L3N_MOSI_CSI_B_MISO0_2), U5.5 (SI/IO0)
unnamed: R44.1, R45.2, U3.N12 (IO_L1P_CCLK_2), U5.6 (SCLK)
unnamed: R43.1, U5.2 (SO/IO1)
unnamed: R46.2, U3.R14 (DONE_2)
unnamed: R43.2, U3.P11 (IO_L3P_D0_DIN_MISO_MISO1_2)
unnamed: R47.2, R48.1, U3.R2 (PROGRAM_B_2)
unnamed: R49.1, U3.P3 (IO_L65P_INIT_B_2)

Notes on the sheet:
Do not populate

Parts:
J6: HDMI
U3: XC6SLX9
U7: FXMHD103

Connections:
+3.3V: U7.11 (VCCA); also elsewhere on the board
GND: J6.2 (TMDS_D2G), J6.5 (TMDS_D1G), J6.8 (TMDS_D0G), J6.11 (TMDS_ClkG), J6.17 (GND), U3.B2 (IO_L1P_HSWAPEN_0), U7.4 (GND); also elsewhere on the board
unnamed: J6.3 (TMDS_D2-), U3.A9 (IO_L37N_GCLK12_0)
unnamed: J6.6 (TMDS_D1-), U3.E8 (IO_L38N_VREF_0)
unnamed: J6.4 (TMDS_D1+), U3.F8 (IO_L38P_0)
unnamed: J6.10 (TMDS_Clk+), U3.C8 (IO_L36P_GCLK15_0)
unnamed: J6.1 (TMDS_D2+), U3.B9 (IO_L37P_GCLK13_0)
unnamed: J6.12 (TMDS_Clk-), U3.A8 (IO_L36N_GCLK14_0)
unnamed: J6.18 (+5V@.05A), U7.5 (VCCC)
unnamed: J6.7 (TMDS_D0+), U3.D10 (IO_L39P_0)
unnamed: J6.9 (TMDS_D0-), U3.C9 (IO_L39N_0)
unnamed: J6.13 (CEC), U7.8 (CEC_C)
unnamed: J6.19 (HP), U7.9 (HPD_C)
unnamed: U3.E9 (IO_L40N_0), U7.1 (SCL_H)
unnamed: J6.16 (SDA), U7.6 (SDA_C)
unnamed: J6.15 (SCL), U7.7 (SCL_C)
unnamed: U3.F10 (IO_L40P_0), U7.2 (SDA_H)
unnamed: U3.B11 (IO_L63P_SCP7_0), U7.12 (CEC_H)
unnamed: U3.A11 (IO_L63N_SCP6_0), U7.10 (HPD_H)
unnamed: U3.D11 (IO_L64P_SCP5_0), U7.3 (OE)

Board: 4 copper layers, 50.8 x 50.8 mm, 129 parts (71 on the bottom side), 133 nets.

## Commit log

2014-07-20 Initial Commit, schematic started.
2014-07-24 Power supply section complete! (hopefully)
2014-07-24 Complete control/storage section (hopefully!)
2014-07-25 Add memory IC schematic symbol.
2014-07-26 Memory power design finished.
2014-07-26 Finish memory layout (hopefully!)
2014-07-28 First checkover of schematic complete, should be working.
2014-07-28 Annotated!
2014-07-28 Some small errors corrected
2014-07-28 minor edits to components to fix some pin assignment issues.
2014-07-29 updated component libraries to solve a few pin issues. Some errors remain but nothing significant.
2014-08-02 Almost completed all footprints.
2014-08-02 minor netlist changes
2014-08-02 More minor netlist changes to make up for incorrectly purchased resistors.
2014-08-02 Final state of 2sqin design, going to move to 4sqin to actually be able to complete the design.
2014-08-03 Capacitor value error correction.
2014-08-03 Fixed issue with vias being too small.
2014-08-09 Started routing DDR again using proper trace widths.
2014-08-21 More edits to the DDR interface
2014-08-21 Added a README.
